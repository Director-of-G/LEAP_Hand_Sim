Commit message: modify reset distribution for 5cm cube

File: assets/leap_hand/robot_cube.urdf (robot description, URDF)
Before this commit: robot onshape, 19 links, 18 joints
Links:
- link object: geometry collision box size=0.05 0.05 0.05; visual box size=0.01 0.01 0.003
